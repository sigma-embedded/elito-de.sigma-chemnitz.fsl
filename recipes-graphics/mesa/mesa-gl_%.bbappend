PACKAGE_ARCH = "fsl-imx6"
COMPATIBLE_MACHINE  = "(-)"
