PACKAGECONFIG_append = " egl glesv2"
